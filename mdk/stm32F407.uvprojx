# Keil uVision project stm32F407.uvprojx, settings and files
target Stm32F407 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: stm32F407
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,HSE_VALUE=8000000
  c include: ..\app;..\driver\console;..\driver\bl_usart;..\driver\led;..\driver\key;..\driver\stm32_flash;..\driver\tim_delay;..\firmware\cmsis\core;..\firmware\cmsis\device;..\firmware\driver\inc;..\third_lib;..\third_lib\crc;..\third_lib\ringbuffer;..\third_lib\utils;..\third_lib\EasyLogger-master\easylogger\inc;..\third_lib\EasyLogger-master\easylogger\port;..\third_lib\EasyLogger-master\easylogger\src;..\third_lib\freertos;..\third_lib\freertos\include;..\third_lib\freertos\portable
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group app
    ../app/: main.c board.c bootloader.c jumpapp.s magic_header.c
  group driver
    ../driver/bl_usart/: bl_usart.c
    ../driver/console/: console.c
    ../driver/tim_delay/: tim_delay.c
    ../driver/key/: key.c
    ../driver/led/: led.c
    ../driver/stm32_flash/: stm32_flash.c
  group firmware/cmsis
    ../firmware/cmsis/device/: startup_stm32f40_41xxx.s system_stm32f4xx.c
  group firmware/driver
    ../firmware/driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group third_lib/crc
    ../third_lib/crc/: crc16.c crc32.c
  group third_lib/ringbuffer
    ../third_lib/ringbuffer/: ringbuffer.c
  group third_lib/easylogger
    ../third_lib/EasyLogger-master/easylogger/port/: elog_port.c
    ../third_lib/EasyLogger-master/easylogger/src/: elog_utils.c elog.c elog_async.c elog_buf.c
  group third_lib/freertos
    ../third_lib/freertos/portable/: heap_4.c port.c
    ../third_lib/freertos/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group third_lib/utils
    ../third_lib/utils/: utils.h
